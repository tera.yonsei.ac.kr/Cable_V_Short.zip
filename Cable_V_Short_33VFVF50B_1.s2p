! Created Tue Jul 15 18:11:31 2008
# hz S ma R 50
! 2 Port Network Data from blockName block
! freq  magS11  angS11  magS21  angS21  magS12  angS12  magS22  angS22
! Worked out from all points (through path):
!   1601 points, 40 MHz to 65 GHz, reference 50 ohm
!   highest |S21| = -0.14 dB at 40 MHz (marker M1); lowest = -5.6 dB at 63.5 GHz (marker M2)
!   lowest |S11| = -62.9 dB at 1.542 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.0469 ohm
!   |S11| at or under -10 dB: start of sweep to 46.89 GHz; 46.89 GHz to 48.8 GHz (1.905 GHz wide, 3.98 % of centre); 48.8 GHz to end of sweep
!   |S22| runs from -51.6 to -8.0 dB; largest |S21 - S12| = 0.063
!   the Smith chart shows 40 MHz to 12.02 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 40 MHz  -33.7  -0.1  -0.1  -31.8
! 486.6 MHz  -41.1  -0.4  -0.4  -39.0
! 1.542 GHz  -62.9  -0.7  -0.7  -44.9
! 10.88 GHz  -27.8  -1.7  -1.7  -25.4
! 15.14 GHz  -22.1  -2.0  -2.0  -26.8
! 18.43 GHz  -28.5  -2.2  -2.2  -24.4
! 19.85 GHz  -22.6  -2.3  -2.3  -34.7
! 21.72 GHz  -30.9  -2.4  -2.4  -17.9
! 24.36 GHz  -16.6  -2.7  -2.6  -24.2
! 26.19 GHz  -14.7  -2.7  -2.6  -16.9
! 28.3 GHz  -20.5  -2.8  -2.8  -19.8
! 32.52 GHz  -26.4  -3.4  -3.3  -22.7
! 36.7 GHz  -24.5  -3.9  -3.9  -33.3
! 43.36 GHz  -20.8  -3.6  -3.6  -16.1
! 47.62 GHz  -14.8  -3.7  -3.7  -19.8
! 49.21 GHz  -11.3  -3.8  -3.6  -17.5
! 54.2 GHz  -31.3  -4.4  -4.4  -18.5
! 57.08 GHz  -21.5  -4.7  -4.6  -19.7
! 60.01 GHz  -25.7  -4.6  -4.7  -20.6
! 61.06 GHz  -21.1  -4.7  -4.8  -20.6
! 63.5 GHz  -15.2  -5.6  -5.4  -11.6
! 65 GHz  -13.6  -5.5  -6.3  -16.9
