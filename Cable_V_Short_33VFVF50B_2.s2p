! Created Tue Jul 15 18:11:39 2008
# hz S ma R 50
! 2 Port Network Data from blockName block
! freq  magS11  angS11  magS21  angS21  magS12  angS12  magS22  angS22
! Worked out from all points (through path):
!   1601 points, 40 MHz to 65 GHz, reference 50 ohm
!   highest |S21| = -0.12 dB at 40 MHz (marker M1); lowest = -4.7 dB at 63.78 GHz (marker M2)
!   lowest |S11| = -52.4 dB at 5.44 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.197 ohm
!   |S11| at or under -10 dB: start of sweep to 47.86 GHz; 47.87 GHz to 49.17 GHz (1.294 GHz wide, 2.67 % of centre); 49.18 GHz to end of sweep
!   |S22| runs from -53.3 to -8.5 dB; largest |S21 - S12| = 0.068
!   the Smith chart shows 40 MHz to 10.07 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 40 MHz  -29.9  -0.1  -0.1  -29.2
! 5.44 GHz  -52.4  -1.1  -1.1  -38.9
! 10.88 GHz  -28.5  -1.6  -1.6  -28.4
! 13.68 GHz  -24.0  -1.8  -1.7  -25.7
! 16.65 GHz  -28.0  -1.9  -1.9  -36.4
! 17.9 GHz  -24.7  -1.9  -2.0  -20.2
! 20.87 GHz  -22.3  -2.0  -2.0  -32.3
! 21.72 GHz  -30.8  -2.1  -2.1  -16.8
! 24.52 GHz  -27.9  -2.1  -2.1  -23.5
! 25.98 GHz  -21.5  -2.0  -2.1  -19.1
! 27.77 GHz  -21.3  -2.3  -2.3  -18.8
! 32.52 GHz  -21.5  -2.8  -2.8  -19.2
! 37.76 GHz  -20.0  -2.8  -2.9  -15.0
! 43.36 GHz  -23.8  -2.6  -2.7  -18.7
! 49.45 GHz  -44.6  -2.9  -2.9  -13.4
! 51.56 GHz  -35.6  -3.1  -3.0  -16.9
! 54.2 GHz  -31.6  -3.5  -3.5  -19.3
! 59.6 GHz  -21.3  -3.9  -3.8  -14.7
! 61.1 GHz  -32.1  -3.8  -4.0  -32.1
! 62.04 GHz  -20.4  -4.0  -4.2  -16.3
! 63.78 GHz  -17.2  -4.7  -4.7  -13.7
! 65 GHz  -13.4  -4.1  -4.9  -33.7
